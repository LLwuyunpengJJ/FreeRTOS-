# Keil uVision project freeRTOS_LY_V3.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FIST
  AfterMake: fromelf --bin !L -o .\BIN\LY_F420_B2.4_S5.4_R121.X2.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --no_multibyte_chars
  c include: ..\TASK\APP;..\TASK\FrameWork;..\RTOS\include;..\RTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\timer;..\SYSTEM\watchdog;..\ALI_3.2_SSL\wrappers;..\ALI_3.2_SSL\dev_model;..\ALI_3.2_SSL\dev_sign;..\ALI_3.2_SSL\dynamic_register;..\ALI_3.2_SSL\infra;..\ALI_3.2_SSL\mqtt;..\ALI_3.2_SSL\wrappers;..\ALI_3.2_SSL\wrappers\temp;..\ALI_3.2_SSL\wrappers\external_libs;..\DEVICE_CODE\ALI;..\DEVICE_CODE\CAN;..\DEVICE_CODE\DISPLAY;..\DEVICE_CODE\HARDWARE;..\DEVICE_CODE\HISTORY;..\DEVICE_CODE\NETWORK;..\DEVICE_CODE\RC522;..\DEVICE_CODE\MAINTAIN;..\DEVICE_CODE\GPS;..\DEVICE_CODE\IC;..\DEVICE_CODE;..\TASK\Frame_Callback
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FRAME_SYS
    ../TASK/FrameWork/system_task/: start_task.c wdg_task.c check_task.c semaphore_init.c
  group SYSTEM
    ../SYSTEM/: main.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: uart.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/watchdog/: watchdog.c
  group RTOS_CORE
    ../RTOS/include/: FreeRTOSConfig.h FreeRTOS.h
    ../RTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS_PORT
    ../RTOS/portable/MemMang/: heap_4.c
    ../RTOS/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
