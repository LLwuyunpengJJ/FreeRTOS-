# Keil uVision project freeRTOS_LY_V1.0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FIST
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\MDK_ARM;..\RTOS\include;..\RTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\timer;..\DEVICE_CODE\init;..\TASK\task1;..\TASK\task2;..\TASK\start_task;..\DEVICE_CODE\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group TASK
    ../TASK/start_task/: start_task.c
    ../TASK/task1/: task1.c
    ../TASK/task2/: task2.c
  group DEVICE_CODE
    ../DEVICE_CODE/init/: init.c
    ../DEVICE_CODE/led/: led.c
  group SYSTEM
    ../SYSTEM/: main.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: uart.c
    ../SYSTEM/timer/: timer.c
  group RTOS_CORE
    ../RTOS/include/: FreeRTOSConfig.h FreeRTOS.h
    ../RTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS_PORT
    ../RTOS/portable/MemMang/: heap_4.c
    ../RTOS/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
